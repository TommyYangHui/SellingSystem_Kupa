# Keil uVision project pro.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./source/: keyboard.c Lcd1602.c main.c Time.c config.h keyboard.h Lcd1602.h main.h Time.h
